require ${LAYERDIR_omnect}/recipes-devtools/rust/rust-source.inc
require ${LAYERDIR_omnect}/recipes-devtools/rust/rust-snapshots.inc
require recipes-devtools/cargo/cargo.inc
BBCLASSEXTEND = "native nativesdk"
