require recipes-devtools/rust/rust-sources.inc
require recipes-devtools/rust/rust-snapshots.inc
require recipes-devtools/cargo/cargo.inc
BBCLASSEXTEND = "native nativesdk"
