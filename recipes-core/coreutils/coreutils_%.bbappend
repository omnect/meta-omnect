ALTERNATIVE_PRIORITY = "${ICS_DM_PRIO_DEFAULT_COREUTILS}"
ALTERNATIVE_PRIORITY[dd] = "${ICS_DM_PRIO_TOOL_COREUTILS}"
