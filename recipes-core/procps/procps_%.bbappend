ALTERNATIVE_PRIORITY = "${ICS_DM_PRIO_DEFAULT_PROCPS}"
ALTERNATIVE_PRIORITY[ps] = "${ICS_DM_PRIO_TOOL_PROCPS}"
