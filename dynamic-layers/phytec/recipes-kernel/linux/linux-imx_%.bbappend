FILESEXTRAPATHS:prepend := "${THISDIR}/linux:"

SRC_URI += "file://0001-feat-linux-imx-added-ramoops-for-tauril2.patch"
