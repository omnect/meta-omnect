# this will only work when building with our kas scripts:
FILESEXTRAPATHS:prepend := "${LAYERDIR_omnect}/../ext/meta-freescale/recipes-bsp/imx-mkimage/files:"
# no kas alternative:
FILESEXTRAPATHS:prepend := "${LAYERDIR_omnect}/../meta-freescale/recipes-bsp/imx-mkimage/files:"
