FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://netfilter_security_table.cfg"
