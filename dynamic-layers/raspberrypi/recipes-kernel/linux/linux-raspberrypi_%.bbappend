FILESEXTRAPATHS:prepend := "${THISDIR}/linux:"

# TEST: temporarily disable ramoops reserved-memory node to check CMA interaction
# SRC_URI += "file://linux-bcm2711-rpi-dtsi-ramoops.patch"
