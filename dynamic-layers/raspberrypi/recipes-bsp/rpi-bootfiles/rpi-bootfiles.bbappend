# override meta-raspberrypi kirkstone firmware version
RPIFW_DATE = "20230509~buster"
SRC_URI[sha256sum] = "1d9eb83111826b708f461101766fd2000d45f1c171ad573936d000f623ca8098"
